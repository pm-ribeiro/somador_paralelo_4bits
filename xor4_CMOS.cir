* This description was generated by JELIS
.include ams35ps.lib

V0 gnd 0 DC 0V
V1 vdd 0 DC 3.3V

* The primary input is: a

Vin1 a gnd pulse 			(0 3.3 0 0.1ns 0.1ns 5n 10.2n)
Vin2 b gnd pulse 			(0 3.3 0 0.1ns 0.1ns 10.1n 20.4n)
Vin3 cin_entrada gnd pulse 	(0 3.3 0 0.1ns 0.1ns 20.3n 40.8n)

.SUBCKT Cout a b cin not_out vdd gnd
*.PININFO a:I b:I cin:I not_out:O vdd:P gnd:G
*.EQN not_out=!((!cin * !a) + (!b * a * !cin) + (!b * cin * !a));
MP1 out a pu_n1 vdd modp W=150u L=0.3u
MP2 out not_a pu_n3 vdd modp W=150u L=0.3u
MP3 pu_n1 cin vdd vdd modp W=150u L=0.3u
MP4 pu_n1 not_cin pu_n5 vdd modp W=150u L=0.3u
MP5 pu_n5 b vdd vdd modp W=150u L=0.3u
MP6 pu_n3 cin pu_n5 vdd modp W=150u L=0.3u
MN7 out not_a pd_n1 gnd modn W=50u L=0.3u
MN8 out a pd_n3 gnd modn W=50u L=0.3u
MN9 pd_n1 cin pd_n4 gnd modn W=50u L=0.3u
MN10 pd_n4 b gnd gnd modn W=50u L=0.3u
MN11 pd_n3 not_cin pd_n4 gnd modn W=50u L=0.3u
MN12 pd_n3 cin gnd gnd modn W=50u L=0.3u
MP_inv13 not_a a vdd vdd modp  W=150u L=0.3u
MN_inv14 not_a a gnd gnd modn  W=50u L=0.3u
MP_inv15 not_cin cin vdd vdd modp  W=150u L=0.3u
MN_inv16 not_cin cin gnd gnd modn  W=50u L=0.3u
MP_inv17 not_out out vdd vdd modp  W=150u L=0.3u
MN_inv18 not_out out gnd gnd modn  W=50u L=0.3u
.ENDS Cout

.SUBCKT cin a b cin not_out vdd gnd
*.PININFO a:I b:I cin:I not_out:O vdd:P gnd:G
*.EQN not_out=!(!b * !a * cin);
MP1 out a pu_n1 vdd modp  W=150u L=0.3u
MP2 pu_n1 not_cin pu_n3 vdd modp W=150u L=0.3u
MP3 pu_n3 b vdd vdd modp W=150u L=0.3u
MN4 out not_a pd_n1 gnd modn W=50u L=0.3u
MN5 out a gnd gnd modn W=50u L=0.3u
MN6 pd_n1 not_cin gnd gnd modn W=50u L=0.3u
MN7 pd_n1 cin pd_n4 gnd modn W=50u L=0.3u
MN8 pd_n4 b gnd gnd modn W=50u L=0.3u
MP_inv9 not_a a vdd vdd modp W=150u L=0.3u
MN_inv10 not_a a gnd gnd modn W=50u L=0.3u
MP_inv11 not_cin cin vdd vdd modp W=150u L=0.3u
MN_inv12 not_cin cin gnd gnd modn W=50u L=0.3u
MP_inv13 not_out out vdd vdd modp W=150u L=0.3u
MN_inv14 not_out out gnd gnd modn W=50u L=0.3u
.ENDS cin

* entrada saida(s) vcc gnd nome da celula
X1 a b cin_entrada cout1 vdd gnd Cout
X2 a b cin_entrada s	 vdd gnd cin

* The output signal is: s

.tran 0.0002ns 50ns

.probe

.end
